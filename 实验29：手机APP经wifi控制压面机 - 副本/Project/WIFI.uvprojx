# Keil uVision project WIFI.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: wifi +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Common;..\Main;..\Startup_config;..\STM32F4_FWLIB\inc;..\USER\BEEP;..\USER\KEY;..\USER\LED;..\USER\usart4_wifi;..\USER\LCD;..\USER\DS18B20;..\USER\RTC;..\USER\TIMER;..\USER\usart4_wifi;..\USER\usart3;..\USER\GPIO;..\USER\usart1;.\LIST;..\STM32F4_FWLIB\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../Main/: main.c stm32f4xx_it.c
  group Startup_config
    ../Startup_config/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group USER
    ../USER/KEY/: key.c
    ../USER/LED/: led.c
    ../USER/LCD/: lcd.c
    ../USER/BEEP/: beep.c
    ../USER/usart4_wifi/: usart4_wifi.c
    ../USER/RTC/: rtc.c
    ../USER/DS18B20/: DS18B20.c
    ../USER/usart3/: usart3.c
    ../USER/GPIO/: gpiod.c
    ../USER/TIMER/: tim.c
    ../USER/usart1/: usart1.c
  group STM32F4_FWLIB
    ../STM32F4_FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_fsmc.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_exti.c stm32f4xx_tim.c
  group Common
    ../Common/: common.c
